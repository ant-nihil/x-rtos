# Keil uVision project stm32f411ceu6_example.uvprojx, settings and files
target x-rtos (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f411ceu6_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\..\F411CEU6;..\..\..\..\..\bsp\stm32\libraries\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\bsp\stm32\libraries\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\Include;..\..\..\..\..\bsp\stm32\libraries\STM32F4xx_DSP_StdPeriph_Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\include;..\..\..\..\..\bsp\stm32\libraries\HAL_Drivers;..\..\..\..\..\hal\stm32\uart;..\..\..\..\..\hal\stm32\led;..\..\..\..\..\hal\stm32\heart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: main.c stm32f4xx_it.c
  group Startup
    ../../../../../bsp/stm32/libraries/STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group CMSIS
    ../../../../../bsp/stm32/libraries/STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../../bsp/stm32/libraries/STM32F4xx_DSP_StdPeriph_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Hal
    ../../../../../hal/: led.c
    ../../../../../hal/stm32/heart/: stm32_heart.c
    ../../../../../hal/stm32/led/: stm32_led.c
    ../../../../../hal/stm32/uart/: stm32_usart.c
  group Include
    ../: stm32f411ceu6_includes.h
  group X-rtos
    ../../../../../src/: os_task_manager.c x_rtos.c
  group Asm
    ../../../../../libcpu/arm/cortex-m4/: rtos.S
